# IAR project smartbike.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0xff
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group Bluetooth
    src/: bluetooth.c bluetooth.h
  group Hall Effect
    src/: hall_effect.c hall_effect.h
  group i2c
    src/: i2c.c
  group IMU
    src/: MPU6050_control.c MPU6050_control.h
  group misc
    src/: button.c button.h common.c common.h i2c.h main.c smart_bike_package.h user_config.h
  group Servos
    src/: servos.c servos.h
  group UART
    src/: uart.c uart.h
